# IAR project STM32F407_FreeRTOS.ewp, settings and files
configuration STM32F407_FreeRTOS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../App/LED/; ../App/BEEP/; ../App/USART/; ../App/ASSERT/; ../App/KEY/; ../App/PWM/; ../App/InputCapture/; ../App/TPAD/; ../App/USMART/; ../App/SYSDLIB/; ../App/LOGPRINT/; ../App/RTC/; ../App/RNG/; ../App/CAN/; ../App/J1939/; ../App/RINGBUFFER/; ../App/WAKEUP/; ../App/ADC/; ../App/DAC/; ../App/PWMADC/; ../App/IIC/; ../App/24CXX/; ../App/SPI/; ../App/W25QXX/; ../App/BMS/; ../App/REMOTE/; ../App/FLASH/; ../App/SRAM/; ../App/XMRAM/; ../App/BMSJ1939/; ../App/BMSBMS/; ../App/MALLOC/; ../App/CHARGEINF/; ../App/ChargeControl/; ../App/PUBLIC/; ../App/I2S/; ../App/WM8978/; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../App/LAN8720/; ../App/LWIPAPP/; ../App/TCPCLIENT/
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: STM32F407_FreeRTOS.hex
  ILINK.IlinkOutputFile: STM32F407_FreeRTOS.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\App\XMRAM\XMRAM.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/APP/24CXX
    ../App/24CXX/: 24cxx.c
  group Application/APP/ADC
    ../App/ADC/: app_adc.c
  group Application/APP/ASSERT
    ../App/ASSERT/: assert.h
  group Application/APP/BEEP
    ../App/BEEP/: beep.c
  group Application/APP/BMS
    ../App/BMS/: BMS.c
  group Application/APP/BMSBMS
    ../App/BMSBMS/: BMS_BMS.c
  group Application/APP/BMSJ1939
    ../App/BMSJ1939/: BMS_J1939x.c
  group Application/APP/CAN
    ../App/CAN/: app_can.c
  group Application/APP/CAPTURE
    ../App/InputCapture/: inputCapture.c
  group Application/APP/CHARGECONTROL
    ../App/ChargeControl/: ChargeControl.c HvProcess_BmsCom.c HvProcess_BmsCom_Lcfg.c HvProcess_Chg.c HvProcess_Chg_Lcfg.c
  group Application/APP/CHARGEINF
    ../App/CHARGEINF/: ChargeInf.c
  group Application/APP/DAC
    ../App/DAC/: app_dac.c
  group Application/APP/FLASH
    ../App/FLASH/: APP_Flash.c
  group Application/APP/IIC
    ../App/IIC/: drive_iic.c
  group Application/APP/IIS
    ../App/I2S/: APP_I2S.c
  group Application/APP/J1939
    ../App/J1939/: J1939x.c
  group Application/APP/KEY
    ../App/KEY/: key.c
  group Application/APP/LAN8720
    ../App/LAN8720/: lan8720.c
  group Application/APP/LED
    ../App/LED/: led.c
  group Application/APP/LOGPRINT
    ../App/LOGPRINT/: log_printf.c
  group Application/APP/LWIPAPP
    ../App/LWIPAPP/: lwip_comm.c
  group Application/APP/MALLOC
    ../App/MALLOC/: malloc.c
  group Application/APP/PUBLIC
    ../App/PUBLIC/: HvProcess_Types.c
  group Application/APP/PWM
    ../App/PWM/: pwm.c
  group Application/APP/PWMADC
    ../App/PWMADC/: pwmadc.c
  group Application/APP/REMOTE
    ../App/REMOTE/: remote.c remote_control.c
  group Application/APP/RINGBUFFER
    ../App/RINGBUFFER/: Ringbuff_manger.c
  group Application/APP/RNG
    ../App/RNG/: app_rng.c
  group Application/APP/RTC
    ../App/RTC/: app_rtc.c
  group Application/APP/SPI
    ../App/SPI/: drive_spi.c
  group Application/APP/SRAM
    ../App/SRAM/: sram.c
  group Application/APP/SYSDLIB
    ../App/SYSDLIB/: sys_stdlib.c
  group Application/APP/TCPCLIENT
    ../App/TCPCLIENT/: tcp_client.c
  group Application/APP/TPAD
    ../App/TPAD/: tpad.c
  group Application/APP/USART
    ../App/USART/: APP_USART.c
  group Application/APP/USMART
    ../App/USMART/: usmart.c usmart_config.c usmart_FunExe.c usmart_receiveFromUsart.c usmart_str.c
  group Application/APP/W25QXX
    ../App/W25QXX/: w25qxx.c
  group Application/APP/WAKEUP
    ../App/WAKEUP/: wakeup.c
  group Application/APP/WM8978
    ../App/WM8978/: wm8978.c
  group Application/APP/XMRAM
    ../App/XMRAM/: XMRAM.h XMRAM.lib
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c can.c dac.c dma.c ethernetif.c freertos.c fsmc.c gpio.c i2s.c lwip.c main.c rng.c rtc.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c tim.c usart.c main.c gpio.c adc.c can.c dac.c dma.c freertos.c fsmc.c i2s.c lwip.c ethernetif.c rng.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
    ..//Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_eth.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c mqtt.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c sys_arch.c
